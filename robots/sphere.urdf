Commit message: backup

File: robots/sphere.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=textured_sphere_smooth.obj scale=0.1 0.1 0.1
