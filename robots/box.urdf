Commit message: add differential optimization

File: robots/box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link baselink: geometry visual box size=0.2 1.0 0.005
